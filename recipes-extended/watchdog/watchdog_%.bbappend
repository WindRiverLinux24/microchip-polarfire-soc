SYSTEMD_AUTO_ENABLE:microchip-polarfire-soc = "enable"
