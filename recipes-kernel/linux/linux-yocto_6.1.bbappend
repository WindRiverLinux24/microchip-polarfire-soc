require linux-yocto-mpfsoc-icicle.inc

KBRANCH:microchip-polarfire-soc  = "v6.1/standard/microchip-polarfire-soc"
