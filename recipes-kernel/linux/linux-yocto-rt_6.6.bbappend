require linux-yocto-mpfsoc-icicle.inc

KBRANCH:microchip-polarfire-soc  = "v6.6/standard/preempt-rt/microchip-polarfire-soc"

